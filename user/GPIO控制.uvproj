# Keil uVision project GPIO控制.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GPIO控制 +hex
  c flags: Optim=1 uC99=1
  c include: ..\CMSIS;..\Library\inc;..\Utilities\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./: main.c startup_stm32f10x_md.s
  group Utilities
    ../Library/src/: stm32f10x_it.c
    ../Utilities/src/: lcd.c delay.c debug.c led.c usart.c
    ./: ov7670.c key.c string.c ov7670.h
  group Library
    ../Library/src/: stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_exti.c misc.c stm32f10x_tim.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
